PACKAGECONFIG:append = " gstreamer"
EXTRA_OEMESON:remove = "-Dgstreamer=disabled"
